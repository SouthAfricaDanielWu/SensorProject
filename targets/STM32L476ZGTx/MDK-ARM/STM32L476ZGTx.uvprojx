# Keil uVision project STM32L476ZGTx.uvprojx, settings and files
target Sensor_Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L476ZGTx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,MBEDTLS_CONFIG_FILE=<los_mbedtls_config.h>,WITH_LWM2M,LWM2M_LITTLE_ENDIAN,LWM2M_CLIENT_MODE,NDEBUG,WITH_AT_FRAMEWORK,USE_NB_NEUL95_NO_ATINY,WITH_SOTA
  c misc: --diag_suppress=1,47,177,186,223,1294,1295
  c include: ..\Inc;..\..\..\include\osdepends\liteos;..\OS_CONFIG;..\Drivers\STM32L4xx_HAL_Driver\Inc;..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\components\connectivity\lwm2m\core\er-coap-13;..\..\..\components\connectivity\lwm2m\core;..\..\..\components\connectivity\lwm2m\examples\shared;..\..\..\components\security\mbedtls\mbedtls_port;..\..\..\components\security\mbedtls\mbedtls-2.6.0\include;..\..\..\include;..\Hardware\E53_IA1;..\Hardware\LCD;..\Hardware\Inc;..\..\..\demos;..\..\..\kernel\include;..\..\..\kernel\base\include;..\..\..\kernel\extended\include;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\common\cmsis;..\..\..\components\ota\flag_operate;..\..\..\components\ota\utility;..\..\..\tests\cmockery\src\google;..\..\..\components/connectivity/agent_tiny/atiny_lwm2m;..\..\..\osdepends\liteos\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: ..\Export\Outputing\STM32L476ZGTx-LiteOS.sct
  group Application/MDK-ARM
    ./: los_startup_keil.s
  group user
    ../Src/: system_stm32l4xx.c dwt.c sys_init.c at_hal.c main.c gpio.c usart.c i2c.c spi.c user_task.c flash_adaptor.c ota_port.c
    ../Lib/: hwpatch.lib
  group at_device
    ../../../components/net/at_device/nb_bc95/: bc95.c
    ../../../components/net/at_device/wifi_esp8266/: esp8266.c
    ../../../components/net/at_device/gprs_M26/: m26.c
  group liteos/cmsis
    ../../../osdepends/liteos/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group liteos/arch
    ../../../arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rng.c stm32l4xx_hal_spi.c stm32l4xx_hal_qspi.c
  group hardware
    ../Hardware/Src/: hal_iwdg.c hal_rng.c hal_qspi_flash.c
    ../Hardware/E53_IA1/: E53_IA1.c
  group mbedtls
    ../../../components/security/mbedtls/mbedtls-2.6.0/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c CMakeLists.txt ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls_port
    ../../../components/security/mbedtls/mbedtls_port/: dtls_interface.c entropy_hardware_poll.c net_sockets_alt.c timing_alt.c
  group os_depends
    ../../../osdepends/liteos/: atiny_osdep.c
  group nb_iot_demo
    ../../../demos/nbiot_without_atiny/: sota_demo.c nb_demo.c nb_cmd_ioctl.c
  group at_framework
    ../../../components/net/at_frame/: at_api.c at_main.c
  group nb-iot_api
    ../../../components/connectivity/nb_iot/: los_nb_api.c
  group ota
    ../../../components/ota/flag_operate/: flag_manager.c upgrade_flag.c
    ../../../components/ota/sota/: sota.c sota_hal.c ota_default.c ota.c
    ../../../components/ota/utility/: ota_crc.c ota_sha256.c
    ../../../components/ota/package/: package.c package_checksum.c package_head.c package_writer.c
  group atiny_dep
    ../../../components/lib/libc/: malloc.c errno.c
    ../../../components/net/sal/: atiny_socket.c
  group log
    ../../../components/log/: atiny_log.c
